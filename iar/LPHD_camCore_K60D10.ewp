# IAR project LPHD_camCore_K60D10.ewp, settings and files
configuration RAM (ARM, debug)
  General.OGChipSelectEditMenu: MK60DN512xxx10 Freescale MK60DN512xxx10
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: LPLD_K60; USE_K60D10
  ICCARM.CCIncludePath2: ..\app; ..\..\..\lib\CPU; ..\..\..\lib\common; ..\..\..\lib\LPLD; ..\..\..\lib\LPLD\HW; ..\..\..\lib\LPLD\DEV; ..\..\..\lib\LPLD\FUNC; ..\..\..\lib\uCOS-II\Ports; ..\..\..\lib\uCOS-II\Source; ..\..\..\lib\FatFs; ..\..\..\lib\FatFs\option; ..\..\..\lib\USB\common; ..\..\..\lib\USB\driver; ..\..\..\lib\USB\descriptor; ..\..\..\lib\USB\class
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: LPHD_camCore_K60D10.bin
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60DN512_RAM.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration FLASH (ARM, debug)
  as the first configuration, except:
  ICCARM.CCIncludePath2: ..\app; ..\app\camera; ..\app\led; ..\app\oled; ..\app\task; ..\app\uart; ..\app\twinCore; ..\app\mpu6050; ..\app\nrf; ..\app\calc; ..\app\UI; ..\app\ledArray; ..\lib\CPU; ..\lib\common; ..\lib\LPLD; ..\lib\LPLD\HW; ..\lib\LPLD\DEV; ..\lib\LPLD\FUNC; ..\lib\uCOS-II\Ports; ..\lib\uCOS-II\Source; ..\lib\FatFs; ..\lib\FatFs\option; ..\lib\USB\common; ..\lib\USB\driver; ..\lib\USB\descriptor; ..\lib\USB\class
  ILINK.IlinkIcfFile: ..\lib\iar_config_files\LPLD_K60DN512_FLASH.icf
configuration BOOT (ARM, debug)
  as the first configuration, except:
  ILINK.IlinkIcfFile: ..\..\..\lib\iar_config_files\LPLD_K60DN512_BOOT.icf
  group app
    ../app/calc/: calc.c
    ../app/camera/: camera.c
    ../app/mpu6050/: i2c.c mpu6050.c
    ../app/: k60_card.h LPHD_camCore.c
    ../app/led/: led.c
    ../app/ledArray/: ledArray.c
    ../app/nrf/: nrf.c
    ../app/oled/: oled.c
    ../app/task/: task.c
    ../app/twinCore/: twinCore.c
    ../app/uart/: uart.c
    ../app/UI/: UI.c UIStrings.c
  group lib/common
    ../lib/common/: alloc.c assert.c assert.h common.h io.c io.h lib_def.h relocate.c relocate.h
  group lib/CPU
    ../lib/CPU/: startup_K60D10.s system_MK60.c
  group lib/LPLD/DEV
    ../lib/LPLD/DEV/: DEV_SCCB.c DEV_SCCB.h
  group lib/LPLD/HW
    ../lib/LPLD/HW/: HW_ADC.c HW_ADC.h HW_CAN.c HW_CAN.h HW_DAC.c HW_DAC.h HW_DMA.c HW_DMA.h HW_ENET.c HW_ENET.h HW_FLASH.c HW_FLASH.h HW_FLEXBUS.c HW_FLEXBUS.h HW_FTM.c HW_FTM.h HW_GPIO.c HW_GPIO.h HW_I2C.c HW_I2C.h HW_LPTMR.c HW_LPTMR.h HW_MCG.c HW_MCG.h HW_NVIC.c HW_NVIC.h HW_PDB.c HW_PDB.h HW_PIT.c HW_PIT.h HW_RTC.c HW_RTC.h HW_SDHC.c HW_SDHC.h HW_SPI.c HW_SPI.h HW_SYSTICK.c HW_SYSTICK.h HW_TSI.c HW_TSI.h HW_UART.c HW_UART.h HW_USB.c HW_USB.h HW_WDOG.c HW_WDOG.h
